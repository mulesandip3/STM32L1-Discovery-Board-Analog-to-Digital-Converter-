# Keil uVision project adc_lcd.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32L100RC STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: adc_lcd
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\adc_lcd_W;.\CMSIS\Device\ST\STM32L1xx\Include;.\CMSIS\Device\ST\STM32L1xx\Source;.\CMSIS\Include;.\STM32L1xx_StdPeriph_Driver\inc;.\STM32L1xx_StdPeriph_Driver\src
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source Group 1
    ./: main.c main.h stm32l1xx_conf.h adc_lcd.c lcd.c button.c led.c
    ./STM32L1xx_StdPeriph_Driver/inc/: stm32l1xx_rcc.h stm32l1xx_adc.h stm32l1xx_gpio.h
    ./STM32L1xx_StdPeriph_Driver/src/: stm32l1xx_adc.c stm32l1xx_gpio.c stm32l1xx_rcc.c
software components: CMSIS:CORE 5.0.1, Device:Startup 2.0.0
